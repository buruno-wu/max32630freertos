# Keil uVision project freertos.uvprojx, settings and files
target MAX32631 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MAX32631 Maxim
  pack: Maxim.MAX32630.0.0.0-1.alpha
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=MAX32631,TARGET_REV =0x4132,ARM_MATH_CM4
  c include: ..\FreeRTOSDemo;.\Libraries\Boards\Include;.\Libraries\Boards\EvKit_V1\Include;.\Libraries\FreeRTOS\Source\include;.\Libraries\MAX3263XPeriphDriver\Include;.\Libraries\ZLG_GUI;.\Libraries\CMSIS\Include;.\Libraries\FreeRTOS\Source\portable;.\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\BTLEHRPDemo\Include;.\NDALibraries\exactLE\src\apps\app\include;.\NDALibraries\exactLE\src\wsf\include;.\NDALibraries\exactLE\src\hci\include;.\NDALibraries\exactLE\src\services;.\NDALibraries\exactLE\src\wsf\generic;.\NDALibraries\exactLE\src\util;.\NDALibraries\exactLE\src\stack\include;.\NDALibraries\exactLE\src\stack\cfg;.\NDALibraries\exactLE\src\profiles\bas;.\NDALibraries\exactLE\src\profiles\hrps;.\Libraries\jansson\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group APP
    ./: main.c freertos_lp1.c
  group BSP
    ./Libraries/Boards/Source/: algorithm.c bmi160.c bmi160_support.c IMU.c LCD12864.c led.c max14690.c MAX30100.c max30102.c pb.c SHTxx.C stdio.c BSP_UART.c
    ./Libraries/Boards/EvKit_V1/Source/: board.c
    ./: rtcop.c
  group HAL
    ./Libraries/MAX3263XPeriphDriver/Source/: adc.c aes.c clkman.c crc.c flc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group GUI
    ./Libraries/ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C hz.c lcmdrv.c loadbit.c menu.c spline.c vbatmon.c windows.c
  group FREERTOS
    ./Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOSPORT
    ./Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group CMSIS
    ./Libraries/CMSIS/Device/Maxim/MAX3263X/Source/: system_max3263x.c
    ./Libraries/CMSIS/Device/Maxim/MAX3263X/Source/ARM/: startup_max3263x.s
software components: Data Exchange:JSON:Jansson 2.7.0
