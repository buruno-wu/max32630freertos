# IAR project Backup of FreeRTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32620 Maxim MAX32620
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_SPIX_PRAGMA=1; TARGET=MAX3263x; BOARD=EvKit_V1; TARGET_REV=0x4132
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX3263x\Include; ..\..\..\..\Libraries\MAX3263xPeriphDriver\Include; ..\..\..\..\Libraries\FreeRTOS\Source\include; ..\..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\Libraries\MAX3263XPeriphDriver\Include; G:\Maxim\Firmware\MAX3263X\Applications\EvKitExamples\FreeRTOSDemo\IAR; G:\Maxim\Firmware\MAX3263X\Libraries\CMSIS\Device\Maxim\MAX3263X\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX3263X\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../: main.c
  group APP
    ../: CLI-commands.c freertos_lp1.c
    ../../../../Libraries/FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group BSP
    ../../../../Libraries/Boards/Source/: bmi160.c bmi160_support.c led.c max14690.c mx25.c nhd12832.c pb.c stdio.c
    ../../../../Libraries/Boards/EvKit_V1/Source/: board.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/IAR/: startup_max3263x.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/: system_max3263x.c
  group FreeRTOS
    ../../../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Port
    ../../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group HAL
    ../../../../Libraries/MAX3263XPeriphDriver/Source/: adc.c aes.c clkman.c crc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c pmu.c prng.c pt.c rtc.c spim.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group IAR
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/IAR/: cmain.s low_level_init.c
