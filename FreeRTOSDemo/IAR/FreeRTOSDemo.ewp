# IAR project FreeRTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32630 Maxim MAX32630
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_SPIX_PRAGMA=1; TARGET=MAX3263x; BOARD=EvKit_V1; TARGET_REV=0x4132; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX3263x\Include; ..\..\..\..\Libraries\MAX3263xPeriphDriver\Include; ..\..\..\..\Libraries\FreeRTOS\Source\include; ..\..\..\..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\Libraries\MAX3263XPeriphDriver\Include; G:\Maxim\Firmware\MAX3263X\Applications\EvKitExamples\FreeRTOSDemo\IAR; G:\Maxim\Firmware\MAX3263X\Libraries\CMSIS\Device\Maxim\MAX3263X\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX3263X\Include; G:\Maxim\Firmware\MAX3263X\Libraries\ZLG_GUI
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Maxim\MAX32630.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../: main.c
  group APP
    ../: CLI-commands.c freertos_lp1.c
    ../../../../Libraries/FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group BSP
    ../../../../Libraries/Boards/Source/: algorithm.c bmi160.c bmi160_support.c IMU.c LCD12864.c led.c max14690.c MAX30100.c max30102.c nhd12832.c pb.c SHTxx.C stdio.c
    ../../../../Libraries/Boards/EvKit_V1/Source/: board.c
    ../../../../Libraries/ZLG_GUI/: vbatmon.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/IAR/: startup_max3263x.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/: system_max3263x.c
  group FreeRTOS
    ../../../../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Port
    ../../../../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GUI
    ../../../../Libraries/ZLG_GUI/: ConvertColor.c FONT24_32.C font5_7.c FONT8_8.C GUI_BASIC.C GUI_StockC.C hz.c lcmdrv.c loadbit.c menu.c spline.c windows.c
  group HAL
    ../../../../Libraries/MAX3263XPeriphDriver/Source/: adc.c aes.c clkman.c crc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c pmu.c prng.c pt.c rtc.c spim.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
  group IAR
    ../../../../Libraries/CMSIS/Device/Maxim/MAX3263X/Source/IAR/: cmain.s low_level_init.c
